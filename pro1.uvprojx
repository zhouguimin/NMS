# Keil uVision project pro1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: .\startup;.\User;.\Libraries;.\System;.\FreeRTOS\include;.\FreeRTOS\portable\ARM_CM3;.\User\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Include
    ./User/include/: freertos_demo.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h freertos_demo.c
  group FreeRTOS/Include
    ./FreeRTOS/include/: timers.h task.h stream_buffer.h StackMacros.h stack_macros.h semphr.h queue.h projdefs.h portable.h mpu_wrappers.h mpu_prototypes.h message_buffer.h list.h FreeRTOSConfig.h FreeRTOS.h event_groups.h deprecated_definitions.h croutine.h atomic.h
  group FreeRTOS/Source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group System
    ./System/: Delay.c Delay.h Uart.c Uart.h I2C.c I2C.h BQ76920.c BQ76920.h
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h startup_stm32f10x_ld.s
  group Library
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group FreeRTOS/Portable
    ./FreeRTOS/portable/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
